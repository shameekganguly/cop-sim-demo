Commit message: Negative primitive insertion demo

File: resources/kuka_iiwa/kuka_iiwa_peg_hole1.urdf (robot description, URDF)
Before this commit: robot kuka_iiwa, 8 links, 7 joints
Links:
- link link6: geometry visual capsule length=0.08 radius=0.008; visual capsule length=0.08 radius=0.008
